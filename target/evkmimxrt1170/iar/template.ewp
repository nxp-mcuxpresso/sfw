# IAR project template.ewp, settings and files
configuration sfw (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: sfw.out
  ILINK.IlinkIcfFile: ..\board\link\MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
