# Keil uVision project template.uvprojx, settings and files
target sfw (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.3.0
  cpu: IRAM(0x20000000,0x040000) IRAM2(0x20040000,0x4000) IROM(0x00000000,0x098000) XRAM(0x04000000,0x8000) XRAM2(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: sfw.out
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x4000000 size 0x8000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x4000
  scatter file: ..\board\link\LPC55S69_cm33_core0_flash.scf
  link misc: ../device/LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove
software components: CMSIS:CORE 5.3.0
