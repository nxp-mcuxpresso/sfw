# Keil uVision project template.uvprojx, settings and files
target sfw (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT595SFFOB:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: sfw.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  asm define: DEBUG
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20000 size 0x60000
  memory RVCT8: RAM 0x40140000 size 0x4000
  memory RVCT9: RAM 0x80000 size 0x180000
  memory RVCT10: RAM 0x200000 size 0x280000
  scatter file: ..\board\link\MIMXRT595Sxxxx_cm33_flash.scf
  link misc: --remove --keep=*(.flash_conf)
software components: CMSIS:CORE 5.4.0
