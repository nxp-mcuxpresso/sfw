# IAR project pin_detect_hid_mouse_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 Freescale MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe188,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\rtos; ..\..\..\..\..\platform\utilities\inc; ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\devices; ..\..\..\..\..\platform\devices\MK65F18\include; ..\..\..\..\..\platform\devices\MK65F18\startup; ..\..\..\..\..; ..\..\..\..\stack\osa; ..\..\..\..\stack\hal; ..\..\..\..\stack\host\include\MK65F18; ..\..\..\..\stack\host\include; ..\..\..\..\stack\host\source\class\audio; ..\..\..\..\stack\host\source\class\cdc; ..\..\..\..\stack\host\source\class\hid; ..\..\..\..\stack\host\source\class\hub; ..\..\..\..\stack\host\source\class\msd; ..\..\..\..\stack\host\source\class\phdc; ..\..\..\..\stack\host\source\class\printer; ..\..\..\..\stack\host\source\controller\khci; ..\..\..\..\stack\host\source\controller\ehci; ..\..\..\..\stack\host\source\controller; ..\..\..\..\stack\include; ..\..\..\..\stack\; ..\..\..\..\..\platform\hal\inc; ..\..\..\..\..\platform\drivers\inc; ..\..\..\..\..\platform\drivers\src\uart; ..\..\..\..\..\platform\drivers\src\gpio; ..\..\..\..\..\platform\drivers\src\pit; ..\..\..\..\..\platform\drivers\src\edma; ..\..\..\..\..\platform\system\inc; ..\..\..\..\stack\host\source; ..\..\..\..\..\examples\twrk65f180m; ..\..\..\..\..\platform\system\inc; ..\..; ../../../../../usb_new/stack/device/include; ../../../../../usb_new/stack/device/source/controller/khci; ../../../../../usb_new/stack/device/source/controller/ehci; ../../../../../usb_new/stack/device/source/controller; ../../../../../usb_new/stack/device/source/class/common; ../../../../../usb_new/stack/device/source/class/hid; ../../../../../usb_new/stack/device/source/; ../../../../../usb_new/stack/; ../
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: pin_detect_hid_mouse_bm.srec
  ILINK.IlinkOutputFile: pin_detect_hid_mouse_bm.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x8000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MK65F18/linker/iar/MK65FN2M0xxx18_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K65F18/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/osa/inc; ../../../../../rtos; ../../../../../platform/utilities/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MK65F18/include; ../../../../../platform/devices/MK65F18/startup; ../../../../../; ../../../../../usb_new/stack/osa; ../../../../../usb_new/stack/hal; ../../../../../usb_new/stack/host/include/MK65F18; ../../../../../usb_new/stack/host/include; ../../../../../usb_new/stack/host/source/classes/audio; ../../../../../usb_new/stack/host/source/classes/cdc; ../../../../../usb_new/stack/host/source/classes/hid; ../../../../../usb_new/stack/host/source/classes/hub; ../../../../../usb_new/stack/host/source/classes/msd; ../../../../../usb_new/stack/host/source/classes/phdc; ../../../../../usb_new/stack/host/source/classes/printer; ../../../../../usb_new/stack/host/source/controller/khci; ../../../../../usb_new/stack/host/source/controller/ehci; ../../../../../usb_new/stack/host/source/controller; ../../../../../usb_new/stack/include; ../../../../../usb_new/stack/; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/drivers/src/uart; ../../../../../platform/drivers/src/gpio; ../../../../../platform/drivers/src/pit; ../../../../../platform/drivers/src/edma; ../../../../../platform/system/inc; ../../../../../usb_new/stack/host/source; ../../../../../examples/twrk65f180m; ../../../../../platform/system/inc
  ICCARM.CCOptLevel: 3
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x4000; __heap_size__=0x8000
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K65F18/release/libksdk_platform.a
  group board
    ../../../../../examples/twrk65f180m/: board.c board.h gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h
    ../../freertos/: hardware_init.c
  group source
    ../: app.c app.h device_mouse.c device_mouse.h host_mouse.c host_mouse.h usb_descriptor.c usb_descriptor.h usb_device_config.h usb_host_config.h
  group stack/device/include
    ../../../../stack/device/include/: usb_device.h
  group stack/device/source
    ../../../../stack/device/source/: usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h
  group stack/device/source/class
    ../../../../stack/device/source/class/common/: usb_device_class.c usb_device_class.h
  group stack/device/source/class/hid
    ../../../../stack/device/source/class/hid/: usb_device_hid.c usb_device_hid.h
  group stack/device/source/controller/ehci
    ../../../../stack/device/source/controller/ehci/: ehci_device.c ehci_device.h
  group stack/device/source/controller/khci
    ../../../../stack/device/source/controller/khci/: khci_device.c khci_device.h
  group stack/hal
    ../../../../stack/hal/: fsl_usb_khci_hal.h
  group stack/host/class/hid
    ../../../../stack/host/source/class/hid/: usb_host_hid.c usb_host_hid.h
  group stack/host/class/hub
    ../../../../stack/host/source/class/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group stack/host/include
    ../../../../stack/host/include/MK65F18/: usb_host_config.h
  group stack/host/soc
    ../../../../stack/host/source/soc/MK65F18/: usb_host_soc.c
  group stack/host/source
    ../../../../stack/host/source/: usb_host.h usb_host_devices.c usb_host_devices.h usb_host_framework.c usb_host_framework.h usb_host_hcd.h usb_host_hci.c
  group stack/host/source/EHCI
    ../../../../stack/host/source/controller/ehci/: usb_host_ehci.c usb_host_ehci.h
  group stack/host/source/KHCI
    ../../../../stack/host/source/controller/khci/: usb_host_khci.c usb_host_khci.h
  group stack/include
    ../../../../stack/: usb.h
    ../../../../stack/include/: usb_misc.h usb_spec.h
  group stack/osa
    ../../../../stack/osa/: usb_osa_bm.c usb_osa_bm.h
  group startup
    ../../../../../platform/devices/: startup.c startup.h
    ../../../../../platform/devices/MK65F18/startup/iar/: startup_MK65F18.s
    ../../../../../platform/devices/MK65F18/startup/: system_MK65F18.c
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c fsl_misc_utilities.c print_scan.c print_scan.h
